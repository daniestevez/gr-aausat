<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>aausat_aausat_parser</key>
<param><key>id</key><value>aausat_aausat_parser_0</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/out.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-75</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/daniel/csp.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.005</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0</value></param>
<param><key>access_code</key><value>010011110101101000110100010000110101010101000010</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>8</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>4*1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>aausat_aausat_parser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
